Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T15:45:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 15:45:33 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{6A11E276-9EBB-4AAC-9CC7-D4FB19E0494F}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 15:45:32 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 15:45:33 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 15:45:33 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR133 - GRANITO, Panca LIDO 2500:0PAAR133 - GRANITO:216629
In: 0 - Piano Terra
Type - Material: GRANITO SABBIATO
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca LIDO 2500
Type - Dati identità - BIM Name: LIDO 2500; BIM Object Type: COLLEZIONI - COLLECTIONS; Code: 0PAAR133; Designer: C + S ARCHITECS; Family Name: LIDO; Nome del tipo: 0PAAR133 - GRANITO; URL Eng: https://www.bellitalia.net/en/projects/lido-italy/; URL Ita: https://www.bellitalia.net/realizzazioni/lido-italia/
Type - Dimensioni - Dimensions: 412 mm X ⌀ 2500 mm X r 236 mm X R 1250 mm
Type - Generale - Accessori: Supplemento per illuminazione; Accessories: Supplement for lighting; Descrizione Tecnica Famiglia: "panca a sezione circolare modulare mod. “LIDO 2500”, costituita da una panca monolitica a sezione circolare. A discrezione del committente c’è la possibilità di integrare la panchina con un basamento su misura che garantisce una perfetta planarità e l’integrazione ulteriore con tappo di chiusura in sostituzione dello spazio per fioriera."; Descrizione Tecnica per Codice: PANCA LIDO 2500 IN GRANITO (COLORE A SCELTA) SABBIATO CON PIANO DI SEDUTA LEVIGATO VERNICIATURA ANTI-DEGRADO; Fissaggio: Appoggio; Fixings: Freestanding; Technical Description Family: Circular modular bench model "LIDO 2500", consisting of a monolithic bench with a circular section. At the client's discretion, there is the possibility of integrating the bench with a custom-made base that guarantees perfect flatness. Additionally, there is the option to further integrate the bench with a closing cap instead of the space for a flowerpot.; Technical Description for Article: LIDO 2500 BENCH IN GRANITO (COLOR TO BE CHOSEN) SANDBLASTED WITH POLISHED SEAT SURFACE ANTI-DECAY VARNISH
Type - Materiali e finiture - Materiale Principale: Granito Bianco; Materiale Secondario: Pietre di Granito; MATERIALE SEDUTA: GRANITO SABBIATO; Primary Material: White Granite; Secondary Material: Reconstituted Granite
Type - Meccanica - Weight ( kg): 2421 Kg
Pset_BuildingElementProxyCommon - Reference: 0PAAR133 - GRANITO
Altro - Famiglia: Panca LIDO 2500: 0PAAR133 - GRANITO; Famiglia e tipo: Panca LIDO 2500: 0PAAR133 - GRANITO; ID tipo: Panca LIDO 2500: 0PAAR133 - GRANITO; Tipo: Panca LIDO 2500: 0PAAR133 - GRANITO
Dimensioni - Area: 5.63402 m2; Volume: 0.982623 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
